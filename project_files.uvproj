# Keil uVision project project_files.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2148 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: major_project +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s lcd.c KPM.c UART.c UART1.c I2C.c I2c_Eeprom.c RTC_Defaults.c Check.c DATA.c My_Str_Func.c Officer_interface.c Password.c Voter_Interface.c main.c delay.c
